# Keil uVision project UART.uvprojx, settings and files
target UART (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: UART
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc;C:/Users/Wikiwiki/STM32Cube/Repository/STM32Cube_FW_L4_V1.6.0/Drivers/STM32L4xx_HAL_Driver/Inc;C:/Users/Wikiwiki/STM32Cube/Repository/STM32Cube_FW_L4_V1.6.0/Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;C:/Users/Wikiwiki/STM32Cube/Repository/STM32Cube_FW_L4_V1.6.0/Drivers/CMSIS/Device/ST/STM32L4xx/Include;C:/Users/Wikiwiki/STM32Cube/Repository/STM32Cube_FW_L4_V1.6.0/Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/STM32L4xx_HAL_Driver
    C:/Users/Wikiwiki/STM32Cube/Repository/STM32Cube_FW_L4_V1.6.0/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_flash_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_dma.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Application/User
    ../Src/: stm32l4xx_hal_msp.c stm32l4xx_it.c main.c
    ../: readme.txt
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
software components: CMSIS:CORE 4.1.0
